* Cascode Current Mirror - 20uA with High Output Impedance
* GF180nm 3.3V Process

.title Cascode Current Mirror Design

* Include model file (provided in context)
.include GF180nm_sm141064_simplified.txt

* Power supply
VDD vdd 0 DC 3.3

* Reference current source (ideal for testing)
Iref vdd n_ref DC 20u

* Basic current mirror (bottom transistors)
M1 n_ref n_ref 0 0 nmos_3p3 W=2.2u L=0.22u
M2 n_mid n_ref 0 0 nmos_3p3 W=2.2u L=0.22u

* Cascode transistors (top)
M3 n_out n_casc n_ref 0 nmos_3p3 W=2.2u L=0.22u
M4 n_out n_casc n_mid 0 nmos_3p3 W=2.2u L=0.22u

* Cascode bias generation
* Using diode-connected transistors for self-biasing
M5 n_casc n_casc n_bias 0 nmos_3p3 W=2.2u L=0.22u
M6 n_bias n_ref 0 0 nmos_3p3 W=2.2u L=0.22u

* Bias current for cascode bias circuit
Ibias vdd n_casc DC 20u

* Load capacitor
CL n_out 0 1p

* Test voltage source for output (sweep for Rout measurement)
Vout n_out 0 DC 1.65

* Testbench commands
.control

* Operating point analysis
op
print all

* DC sweep to verify current matching and find output impedance
dc Vout 0.6 3.0 0.01
plot i(Vout)
meas dc iout_at_1p65V find i(Vout) when v(n_out)=1.65

* AC analysis for output impedance at 1kHz
ac dec 10 0.1 10meg
let rout = v(n_out)/i(Vout)
plot mag(rout)
meas ac rout_1k find mag(rout) at=1k

* Verify saturation regions
print @m1[vds] @m1[vgs] @m1[vth]
print @m2[vds] @m2[vgs] @m2[vth]
print @m3[vds] @m3[vgs] @m3[vth]
print @m4[vds] @m4[vgs] @m4[vth]

* Calculate current accuracy
let iref_actual = -i(Iref)
let iout_actual = -i(Vout)
let error_percent = 100*(iout_actual - iref_actual)/iref_actual
print iref_actual iout_actual error_percent

.endc
.end
