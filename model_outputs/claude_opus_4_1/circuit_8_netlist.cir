* Single-Stage OTA Design - GF180nm 3.3V
* Specifications: Av>=40dB, GBW>=10MHz, PM>=60deg, CL=10pF

.include GF180nm_sm141064_simplified.txt

* Power Supply
VDD vdd 0 DC 3.3
VSS vss 0 DC 0

* Input Common Mode and Differential Signals
VCM vcm 0 DC 1.65
VIN_DM vin_dm 0 DC 0 AC 1
EIN_P vinp vcm vin_dm 0 0.5
EIN_N vinn vcm vin_dm 0 -0.5

* OTA Core Circuit
* Differential Pair (NMOS)
M1 vout_n vinp vtail vss nmos_3p3 W=165u L=0.5u
M2 vout vinn vtail vss nmos_3p3 W=165u L=0.5u

* Current Mirror Load (PMOS)
M3 vout_n vout_n vdd vdd pmos_3p3 W=140u L=1u
M4 vout vout_n vdd vdd pmos_3p3 W=140u L=1u

* Tail Current Source
M5 vtail vbias vss vss nmos_3p3 W=210u L=2u

* Bias Circuit for Tail Current
* Simple current mirror bias with resistor reference
RBIAS vdd vbias_ref 33k
M6 vbias_ref vbias_ref vss vss nmos_3p3 W=10u L=2u
M7 vbias vbias_ref vss vss nmos_3p3 W=10u L=2u

* Load Capacitor
CL vout 0 10p

* Initial Conditions (helps convergence)
.nodeset v(vbias)=0.9 v(vtail)=0.2 v(vout)=1.65

* Analyses
* Operating Point
.op

* DC Sweep for Input Common Mode Range
.dc VCM 0 3.3 0.01

* AC Analysis for Frequency Response
.ac dec 100 1 1G

* Transient Analysis for Step Response
.tran 1n 10u

* Control Statements
.control
* Run operating point
op
echo "========== Operating Point Results =========="
echo "Tail Current (M5):"
print @m5[id]
echo "M1 Current:"
print @m1[id]
echo "M2 Current:"
print @m2[id]
echo "M1 gm:"
print @m1[gm]
echo "M2 gm:"
print @m2[gm]
echo "Output DC Voltage:"
print v(vout)

* Run AC analysis
ac dec 100 1 1G
echo "========== AC Analysis Results =========="
* Find DC gain
meas ac av_db max vdb(vout)
meas ac av_mag max vm(vout)
* Find 3dB frequency
meas ac f3db when vdb(vout)=av_db-3
* Find unity gain frequency (GBW)
meas ac gbw when vm(vout)=1
* Find phase at unity gain for phase margin
meas ac phase_at_ugf find vp(vout) when vm(vout)=1
let pm = 180 + phase_at_ugf
echo "Phase Margin:"
print pm

* Plot frequency response
plot vdb(vout) xlabel 'Frequency (Hz)' ylabel 'Gain (dB)' title 'OTA Frequency Response'
plot vp(vout) xlabel 'Frequency (Hz)' ylabel 'Phase (deg)' title 'OTA Phase Response'

.endc

.end
