* Two-Stage OTA Design - GF180nm 3.3V
* Specifications: Av>60dB, GBW>20MHz, PM>60deg, SR>5V/us
* Total current budget: 100uA

.title Two-Stage Miller-Compensated OTA

* Include models
.include GF180nm_sm141064_simplified.txt

* Supply and input voltages
VDD vdd 0 DC 3.3
VSS vss 0 DC 0

* Input differential voltage with common mode
Vcm vcm 0 DC 1.65
Vin_p vin_p vcm DC 0 AC 0.5
Vin_n vin_n vcm DC 0 AC -0.5

* Load capacitor
CL vout 0 20p

* Two-Stage OTA Circuit
* First Stage - Differential Pair
M1 vd1 vin_p vs1 vss nmos_3p3 W=8u L=0.5u
M2 vd2 vin_n vs1 vss nmos_3p3 W=8u L=0.5u

* First Stage - Active Load (Current Mirror)
M3 vd1 vd1 vdd vdd pmos_3p3 W=4u L=0.5u
M4 vd2 vd1 vdd vdd pmos_3p3 W=4u L=0.5u

* First Stage - Tail Current Source
M5 vs1 vbias1 vss vss nmos_3p3 W=4u L=0.5u

* Second Stage - Common Source Amplifier
M6 vout vd2 vdd vdd pmos_3p3 W=24u L=0.4u
M7 vout vbias2 vss vss nmos_3p3 W=10u L=0.4u

* Miller Compensation
Cc vd2 vout_comp 2p
Rc vout_comp vout 10k

* Bias Circuit
* Reference current source (10uA)
Iref vdd vbias_ref 10u
M8 vbias_ref vbias_ref vss vss nmos_3p3 W=1u L=0.5u

* Current mirror for first stage bias (40uA)
M9 vbias1 vbias_ref vss vss nmos_3p3 W=4u L=0.5u

* Current mirror for second stage bias (60uA)
M10 vbias2 vbias_ref vss vss nmos_3p3 W=6u L=0.5u

* Testbench and Analysis

* DC Operating Point
.op

* AC Analysis for frequency response
.ac dec 100 1 1G

* Transient Analysis for slew rate
.tran 10n 10u

* Control statements
.control
run

* DC Operating Point Check
print all

* AC Analysis - Gain and Phase
echo "AC Analysis Results:"
let gain_db = db(v(vout)/v(vin_p,vin_n))
let phase_deg = phase(v(vout)/v(vin_p,vin_n))*180/pi
print gain_db[0]
meas ac dc_gain find gain_db at=10
meas ac gbw_freq when gain_db=0
meas ac phase_margin find phase_deg when gain_db=0

* Find unity gain frequency and phase margin
let unity_gain_freq = frequency[100]
foreach i 0 1000
  if (gain_db[i] < 0.1) and (gain_db[i] > -0.1)
    let unity_gain_freq = frequency[i]
    let pm = 180 + phase_deg[i]
    print unity_gain_freq
    print pm
    break
  end
end

* Plot frequency response
plot gain_db
plot phase_deg

* Transient Analysis - Slew Rate
* Apply step input
alter Vin_p DC 0 AC 0 PULSE(1.6 1.7 1u 10n 10n 2u 4u)
alter Vin_n DC 0 AC 0 PULSE(1.7 1.6 1u 10n 10n 2u 4u)
tran 10n 10u
let slew_rate_rise = deriv(v(vout))
meas tran sr_max max slew_rate_rise

* Display key metrics
echo ""
echo "=== Two-Stage OTA Performance Summary ==="
echo "DC Gain: should be > 60dB"
print dc_gain
echo "GBW: should be > 20MHz"
print gbw_freq
echo "Phase Margin: should be > 60 degrees"
print phase_margin
echo "Slew Rate: should be > 5V/us"
print sr_max
echo "========================================"

.endc
.end
